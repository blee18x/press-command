<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\press-command.ewp</path>
  </project>
  <batchBuild />
</workspace>
